# Keil uVision project IOEXT.uvprojx, settings and files
target IOEXT (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: IOEXT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../User;../Drivers/CMSIS/DSP/Include;..\Ethercat\Inc;..\Ethercat\port;..\bsp\spiflash;..\bsp\usart;..\bsp\gpio;..\bsp\GeneralTIM;..\bsp\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32g4xx.c
  group User
    ../User/: adc_injected.c adc_injected.h FOC.c FOC.h PLL.c PLL.h Lan9252.c Lan9252.h Lan9252_my.c Lan9252_my.h
  group bsp
    ../User/: el9800appl.c el9800appl.h
    ../Ethercat/port/: el9800hw.c
    ../bsp/usart/: bsp_debug_usart.c
    ../bsp/spiflash/: bsp_spiflash.c
    ../bsp/led/: bsp_led.c
    ../bsp/gpio/: bsp_gpio.c
    ../bsp/GeneralTIM/: bsp_GeneralTIM.c
    ../bsp/key/: bsp_key.c
  group EtherCat/Src
    ../Ethercat/src/: aoeappl.c coeappl.c ecatappl.c foeappl.c cia402appl.c
    ../Ethercat/Inc/: ecat_def.h
  group EtherCat/Stack
    ../Ethercat/src/: bootmode.c diag.c ecataoe.c ecatcoe.c ecateoe.c ecatfoe.c ecatslv.c ecatsoe.c emcy.c eoeappl.c mailbox.c objdef.c sdoserv.c
software components: CMSIS:CORE 4.3.0
